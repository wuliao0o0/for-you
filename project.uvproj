# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\hardware;.\software
  group Source Group 1
    ./: STARTUP.A51 ASCII.h BMP.h main.c port.h public.h STC12C5A60S2.h text.h
  group hardware
    ./hardware/: OLED.c OLED.h ESP8266.c ESP8266.h distance.c step.c step.h
  group software
    ./software/: DELAY.c delay.h eeprom.c eeprom.h I2C.c I2C.h uart.c uart.h distance_timeCount.c distance_timeCount.h
